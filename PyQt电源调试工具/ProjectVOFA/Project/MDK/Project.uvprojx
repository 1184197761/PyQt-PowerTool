# Keil uVision project Project.uvprojx, settings and files
target SRAM (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin !L --output $L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\Drivers\TAE32F53xx_Device\Include;..\..\..\Drivers\TAE32F53xx_Driver\Inc;..\..\User\Include;..\..\..\Utilities;..\..\..\Middlewares\TAE\TAE32F53xx_USB_Device_Library\Class\HID\Inc;..\..\..\Middlewares\TAE\TAE32F53xx_USB_Device_Library\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\SRAM\tae32f53xx_ac5_sram.sct
  link misc: --diag_suppress=L6314W
  group ProjectTemplate/User
    ../../User/Source/: main.c tae32f53xx_it.c tae32f53xx_ll_msp.c user_vofa.c user_tmr.c
  group Documentation
    ../../: readme.md
  group Drivers/TAE_Driver
    ../../../Drivers/TAE32F53xx_Driver/Src/: tae32f53xx_ll.c tae32f53xx_ll_adc.c tae32f53xx_ll_can.c tae32f53xx_ll_cmp.c tae32f53xx_ll_cortex.c tae32f53xx_ll_dac.c tae32f53xx_ll_dali.c tae32f53xx_ll_dflash.c tae32f53xx_ll_dma.c tae32f53xx_ll_ecu.c tae32f53xx_ll_flash.c tae32f53xx_ll_fpll.c tae32f53xx_ll_gpio.c tae32f53xx_ll_hrpwm.c tae32f53xx_ll_i2c.c tae32f53xx_ll_iir.c tae32f53xx_ll_iwdg.c tae32f53xx_ll_lvdctrl.c tae32f53xx_ll_sysctrl.c tae32f53xx_ll_tmr.c tae32f53xx_ll_uart.c tae32f53xx_ll_usb.c tae32f53xx_ll_wwdg.c
  group Drivers/TAE_Device
    ../../../Drivers/TAE32F53xx_Device/Source/: startup_tae32f53xx.c system_tae32f53xx.c
  group Utilities/Debug
    ../../../Utilities/dbg/: user_debug.c
target FLASH (6190000::V6.19::ARMCLANG)
  device: TAE32F5300 Tai-Action
  pack: Tai-Action.TAE32F53xx_DFP.1.4.7
  cpu: IRAM(0x20000000,0x4000) IRAM2(0x20004000,0x1000) IRAM3(0x20005000,0x1000) IROM(0x08000000,0x12c00) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: .\FLASH\AfterBuildHandler.bat $J #L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c include: ..\..\..\Drivers\TAE32F53xx_Device\Include;..\..\..\Drivers\TAE32F53xx_Driver\Inc;..\..\User\Include;..\..\..\Utilities;..\..\..\Middlewares\TM\TAE32F53xx_USB_Device_Library\Class\HID\Inc;..\..\..\Middlewares\TM\TAE32F53xx_USB_Device_Library\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x12c00
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20004000 size 0x1000
  scatter file: .\FLASH\tae32f53xx_ac6_flash.sct
  link misc: --diag_suppress=L6314W
software components: CMSIS:CORE 5.6.0
